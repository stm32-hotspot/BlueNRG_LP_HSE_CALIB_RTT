<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BlueNRG_LP_HSE_CALIB_RTT.ewp</path>
    </project>
    <batchBuild />
</workspace>
